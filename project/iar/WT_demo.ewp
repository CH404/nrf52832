# IAR project WT_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf52832_xxaa NordicSemi nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=7; S132; SOFTDEVICE_PRESENT; SWI_DISABLE0; DEBUG; CONFIG_NFCT_PINS_AS_GPIOS
  ICCARM.CCIncludePath2: ..\..\modules\nrfx\mdk; ..\..\components\softdevice\s132\headers; ..\..\components\toolchain\cmsis\include; ..\..\components\libraries\log; ..\..\components\libraries\experimental_section_vars; ..\..\components\libraries\strerror; ..\..\components\libraries\atomic; ..\..\components\libraries\atomic_fifo; ..\..\components\libraries\atomic_flags; ..\..\components\libraries\balloc; ..\..\components\libraries\crc16; ..\..\components\libraries\fstorage; ..\..\components\libraries\hardfault\nrf52; ..\..\components\libraries\ringbuf; ..\config; ..\..\modules\nrfx\mdk; ..\..\components\softdevice\common; ..\..\components\libraries\log; ..\..\components\libraries\log\src; ..\..\components\libraries\util; ..\..\integration\nrfx; ..\..\components\libraries\memobj; ..\..\components\libraries\mem_manager; ..\..\components\libraries\pwr_mgmt; ..\..\components\ble\ble_advertising; ..\..\components\ble\ble_db_discovery; ..\..\components\ble\peer_manager; ..\..\modules\nrfx; ..\..\external\fprintf; ..\..\components\ble\common; ..\..\components\libraries\uart; ..\..\components\libraries\timer; ..\..\components\libraries\fds; ..\..\modules\nrfx\drivers\include; ..\..\components\libraries\mutex; ..\..\components\libraries\delay; ..\..\components\libraries\gpiote; ..\..\modules\nrfx\hal; ..\..\integration\nrfx\legacy; ..\..\external\segger_rtt; ..\..\components\ble\nrf_ble_gatt; ..\..\components\ble\nrf_ble_qwr; ..\..\components\libraries\hardfault; ..\..\components\libraries\sensorsim; ..\..\app; ..; ..\..\components\ble\ble_services\ble_hrs; ..\..\components\ble\ble_services\ble_dis; ..\..\m_libraries; ..\..\external\freertos\config; ..\..\external\freertos\portable\CMSIS\nrf52; ..\..\external\freertos\portable\IAR\nrf52; ..\..\external\freertos\source\include; ..\..\external\freertos\source\portable\MemMang; ..\..\components\ble\ble_services\ble_bas; ..\..\components\softdevice\s132\headers\nrf52; ..\..\modules\nrfx\soc; ..\..\mpu6050\eMPL; ..\..\mpu6050; ..\..\components\libraries\fifo; ..\..\UIcode
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WT_demo.hex
  ILINK.IlinkOutputFile: WT_demo.out
  ILINK.IlinkIcfFile: D:\nRF5_SDK_15.2.0_9412b96\sdk17\project\iar\ble_app_hrs_freertos_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../../app/: advertising.c app_freertos.c ble_date.c bmp.c common.c it725x.c lcd.c rtc.c saadc.c service.c spi.c st7789.c twi.c
    ../../external/freertos/config/: FreeRTOSConfig.h
    ../: global.c global.h main.c main.h
    ../../mpu6050/: mpu6050.c
    ../config/: sdk_config.h
  group CMSIS
    ../../modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group DMP
    ../../mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group FreeRTOS
    ../../external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../external/freertos/source/portable/MemMang/: heap_4.c
    ../../external/freertos/portable/IAR/nrf52/: port.c
    ../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group nRF_BLE
    ../../components/libraries/timer/: app_timer_freertos.c
    ../../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_spi.c nrf_drv_twi.c nrf_drv_uart.c
    ../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_rtc.c nrfx_saadc.c nrfx_spi.c nrfx_spim.c nrfx_twi.c nrfx_twim.c nrfx_uart.c nrfx_uarte.c nrfx_wdt.c
  group nRF_Libraries
    ../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/uart/: app_uart_fifo.c
    ../../components/libraries/fds/: fds.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Log
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_SoftDevice
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_freertos.c nrf_sdh_soc.c
  group UTF8
    ../../external/utf_converter/: utf.c
